<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Lab4\lab4.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\project1.0.ewp</path>
    </project>
    <batchBuild />
</workspace>
